# IAR project adc_window_monitor_launchpad_tirtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC1350F128 TexasInstruments CC1350F128
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEVICE_FAMILY=cc13x0; DeviceFamily_CC13X0; xdc_runtime_Assert_DISABLE_ALL; xdc_runtime_Log_DISABLE_ALL
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: -f configPkg/compiler.opt.defs
  ICCARM.CCIncludePath2: C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source; C:\ti\simplelink_cc13x0_sdk_2_30_00_20\packages; C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source\ti\boards\CC1350_LAUNCHXL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_window_monitor_launchpad_tirtos.srec
  prebuild: "C:\ti\xdctools_3_50_08_24_core\xs" --xdcpath="C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source;C:\ti\simplelink_cc13x0_sdk_2_30_00_20\kernel\tirtos\packages;C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source\ti\drivers" iar.tools.configuro -c "$TOOLKIT_DIR$" --cc "$COMPILER_PATH$" --device "$DEVICE$" --compileOptions $COMPILER_ARGS_ROOT_QUOTED$ --linkOptions $LINKER_ARGS_QUOTED$ --profile release --projFile "$PROJ_PATH$"
  ILINK.IlinkOutputFile: adc_window_monitor_launchpad_tirtos.out
  ILINK.IlinkConfigDefines: RTOS_ROM=1
  ILINK.IlinkIcfFile: C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source\ti\devices\cc13x0\linker_files\cc13x0f128.icf
  ILINK.IlinkExtraOptions: -f configPkg/linker.cmd
  ILINK.IlinkAdditionalLibs: C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source\ti\devices\cc13x0\driverlib\bin\iar\driverlib.lib; C:\ti\simplelink_cc13x0_sdk_2_30_00_20\source\ti\drivers\lib\drivers_cc13x0.arm3; C:\ti\simplelink_cc13x0_sdk_2_30_00_20\kernel\tirtos\packages\ti\dpl\lib\dpl_cc13x0.arm3
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: rom.cfg
    ../../source/: scif.c scif.h scif_framework.c scif_framework.h scif_osal_tirtos.h main_tirtos.c
  group sdk_files__do_not_edit
    C:/ti/simplelink_cc13x0_sdk_2_30_00_20/source/ti/boards/CC1350_LAUNCHXL/: CC1350_LAUNCHXL.c Board.h CC1350_LAUNCHXL_fxns.c
    C:/ti/simplelink_cc13x0_sdk_2_30_00_20/source/ti/devices/cc13x0/startup_files/: ccfg.c
